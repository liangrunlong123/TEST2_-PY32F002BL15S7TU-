# Keil uVision project Project.uvprojx, settings and files
target Target_1 (6240000::V6.24::ARMCLANG)
  device: PY32F002Bx5 Puya
  pack: Puya.PY32F0xx_DFP.1.2.8
  cpu: IRAM(0x20000000,0x00000C00) IROM(0x08000000,0x00006000) IROM2(0x1FFF0080,0x00000010) XROM(0x1FFF0280,0x00000080) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: Project +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: PY32F002Bx5,USE_HAL_DRIVER
  c include: .\HAL_Driver\HAL_Driver_Inc;.\My_Library;.\User_Application\User_Application_Inc;..\TEST2_版本(PY32F002BL15S7TU);D:\KEIL5\Packs\ARM\CMSIS\6.3.0\CMSIS\Core\Include;.\CMSIS
  memory RVCT1: ROM 0x1fff0280 size 0x80
  memory RVCT4: ROM 0x8000000 size 0x6000
  memory RVCT5: ROM 0x1fff0080 size 0x10
  memory RVCT9: RAM 0x20000000 size 0xc00
  group Common
    ./Common/: startup_py32f002bxx.s system_py32f002b.c
  group User_Application
    ./User_Application/: main.c py32f002b_hal_msp.c py32f002b_it.c
  group HAL_Driver
    ./HAL_Driver/: py32f002b_hal.c py32f002b_hal_adc.c py32f002b_hal_comp.c py32f002b_hal_cortex.c py32f002b_hal_crc.c py32f002b_hal_exti.c py32f002b_hal_flash.c py32f002b_hal_gpio.c py32f002b_hal_i2c.c py32f002b_hal_iwdg.c py32f002b_hal_lptim.c py32f002b_hal_pwr.c py32f002b_hal_rcc.c py32f002b_hal_rcc_ex.c py32f002b_hal_spi.c py32f002b_hal_tim.c py32f002b_hal_tim_ex.c py32f002b_hal_uart.c py32f002b_hal_usart.c
  group My_Library
    ./My_Library/: Timer1.c Timer1.h IO_Init.c IO_Init.h Timer14.c Timer14.h App_Control.c App_Control.h
